## sdkconfig.defaults
```kconfig
# Disable Bluetooth — tidak digunakan, hemat ~150KB flash
CONFIG_BT_ENABLED=n
CONFIG_BLUEDROID_ENABLED=n
CONFIG_BLE_ENABLED=n
CONFIG_BT_CONTROLLER_DISABLED=y
```
